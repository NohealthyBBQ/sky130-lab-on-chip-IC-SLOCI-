v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
B 5 37.5 -162.5 42.5 -157.5 {name=IN1
dir=in}
N -210 -880 30 -880 {
lab=CTRL1}
N -200 -860 30 -860 {
lab=CTRL2}
N -200 -840 30 -840 {
lab=CTRL3}
N -200 -820 30 -820 {
lab=CTRL4}
N -200 -800 30 -800 {
lab=CTRL5}
N 0 -10 30 -10 {
lab=CTRL5}
N -20 -30 30 -30 {
lab=CTRL4}
N -40 -50 30 -50 {
lab=CTRL3}
N -60 -70 30 -70 {
lab=CTRL2}
N -80 -90 30 -90 {
lab=CTRL1}
N 0 -120 30 -120 {
lab=CTRL5}
N -20 -140 30 -140 {
lab=CTRL4}
N -40 -160 30 -160 {
lab=CTRL3}
N -60 -180 30 -180 {
lab=CTRL2}
N -80 -200 30 -200 {
lab=CTRL1}
N 0 -230 30 -230 {
lab=CTRL5}
N -20 -250 30 -250 {
lab=CTRL4}
N -40 -270 30 -270 {
lab=CTRL3}
N -60 -290 30 -290 {
lab=CTRL2}
N -80 -310 30 -310 {
lab=CTRL1}
N 0 -340 30 -340 {
lab=CTRL5}
N -20 -360 30 -360 {
lab=CTRL4}
N -40 -380 30 -380 {
lab=CTRL3}
N -60 -400 30 -400 {
lab=CTRL2}
N -80 -420 30 -420 {
lab=CTRL1}
N 0 -470 30 -470 {
lab=CTRL5}
N -20 -490 30 -490 {
lab=CTRL4}
N -40 -510 30 -510 {
lab=CTRL3}
N -60 -530 30 -530 {
lab=CTRL2}
N -80 -550 30 -550 {
lab=CTRL1}
N 0 -580 30 -580 {
lab=CTRL5}
N -20 -600 30 -600 {
lab=CTRL4}
N -40 -620 30 -620 {
lab=CTRL3}
N -60 -640 30 -640 {
lab=CTRL2}
N -80 -660 30 -660 {
lab=CTRL1}
N 0 -690 30 -690 {
lab=CTRL5}
N -20 -710 30 -710 {
lab=CTRL4}
N -40 -730 30 -730 {
lab=CTRL3}
N -60 -750 30 -750 {
lab=CTRL2}
N -80 -770 30 -770 {
lab=CTRL1}
N 0 -800 -0 -10 {
lab=CTRL5}
N -20 -820 -20 -30 {
lab=CTRL4}
N -40 -840 -40 -50 {
lab=CTRL3}
N -60 -860 -60 -70 {
lab=CTRL2}
N -80 -880 -80 -80 {
lab=CTRL1}
N 90 -880 90 -870 {
lab=4B}
N 90 -880 200 -880 {
lab=4B}
N 90 -800 160 -800 {
lab=GND}
N 90 -770 90 -760 {
lab=4A}
N 90 -770 200 -770 {
lab=4A}
N 90 -690 160 -690 {
lab=GND}
N 90 -660 90 -650 {
lab=3B}
N 90 -660 200 -660 {
lab=3B}
N 90 -580 160 -580 {
lab=GND}
N 90 -550 90 -540 {
lab=3A}
N 90 -550 200 -550 {
lab=3A}
N 90 -470 160 -470 {
lab=GND}
N 90 -420 90 -410 {
lab=2B}
N 90 -420 200 -420 {
lab=2B}
N 90 -340 160 -340 {
lab=GND}
N 90 -310 90 -300 {
lab=2A}
N 90 -310 200 -310 {
lab=2A}
N 90 -230 160 -230 {
lab=GND}
N 90 -200 90 -190 {
lab=1B}
N 90 -200 200 -200 {
lab=1B}
N 90 -120 160 -120 {
lab=GND}
N 90 -90 90 -80 {
lab=4A}
N 90 -90 200 -90 {
lab=4A}
N 90 -10 160 -10 {
lab=GND}
N 160 -800 160 -10 {
lab=GND}
C {hiarachy_final/cap_bank.sym} 20 -10 0 0 {name=X1}
C {hiarachy_final/cap_bank.sym} 20 -120 0 0 {name=X2}
C {hiarachy_final/cap_bank.sym} 20 -230 0 0 {name=X3}
C {hiarachy_final/cap_bank.sym} 20 -340 0 0 {name=X4}
C {hiarachy_final/cap_bank.sym} 20 -470 0 0 {name=X5}
C {hiarachy_final/cap_bank.sym} 20 -580 0 0 {name=X6}
C {hiarachy_final/cap_bank.sym} 20 -690 0 0 {name=X7}
C {hiarachy_final/cap_bank.sym} 20 -800 0 0 {name=X8}
C {ipin.sym} -200 -880 0 0 {name=p1 lab=CTRL1}
C {ipin.sym} -200 -860 0 0 {name=p2 lab=CTRL2}
C {ipin.sym} -200 -840 0 0 {name=p3 lab=CTRL3}
C {ipin.sym} -200 -820 0 0 {name=p4 lab=CTRL4}
C {ipin.sym} -200 -800 0 0 {name=p5 lab=CTRL5}
C {ipin.sym} 160 -10 2 0 {name=p6 lab=GND}
C {ipin.sym} 200 -880 2 0 {name=p7 lab=4B}
C {ipin.sym} 200 -770 2 0 {name=p8 lab=4A}
C {ipin.sym} 200 -660 2 0 {name=p9 lab=3B}
C {ipin.sym} 200 -550 2 0 {name=p10 lab=3A}
C {ipin.sym} 200 -420 2 0 {name=p11 lab=2B}
C {ipin.sym} 200 -310 2 0 {name=p12 lab=2A}
C {ipin.sym} 200 -200 2 0 {name=p13 lab=1B}
C {ipin.sym} 200 -90 2 0 {name=p14 lab=1A}
